<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>fcd_source_c</key>
<param><key>id</key><value>fcd_source_c_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>device_name</key><value>hw:2,0</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>lna</key><value>20.0</value></param>
<param><key>mixer</key><value>+12</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>dci</key><value>0.0</value></param>
<param><key>dcq</key><value>0.0</value></param>
<param><key>iq_phase</key><value>0.0</value></param>
<param><key>iq_gain</key><value>1.0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate*10</value></param>
<param><key>cutoff_freq</key><value>90e3</value></param>
<param><key>width</key><value>8e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>squelch_level</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>squelch_level</value></param>
<param><key>value</key><value>-15</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>squelch_level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>gr_probe_avg_mag_sqrd_x_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>gr_simple_squelch_cc</key>
<param><key>id</key><value>gr_simple_squelch_cc_0</value></param>
<param><key>threshold</key><value>10*math.log10(max(1e-9, squelch_level))+7</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>rtl=0,buffers=16</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate*10</value></param>
<param><key>freq0</key><value>868.403e6</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>gain_mode0</key><value>1</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>value</key><value>868.388e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/avian/hacks/energycount3000/stuff.wav</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
</block>
<block>
<key>gr_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>gr_probe_avg_mag_sqrd_x_0</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>1.0/samp_rate/1e2</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>1</value></param>
<param><key>v_offset</key><value>0.5</value></param>
<param><key>t_scale</key><value>0.5e-3</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>gr_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>gr_add_const_vxx</key>
<param><key>id</key><value>gr_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-1e-3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>gr_char_to_float</key>
<param><key>id</key><value>gr_char_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>255</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_float_to_uchar</key>
<param><key>id</key><value>gr_float_to_uchar_0</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>ec3k.pipe</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>gr_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_simple_squelch_cc_0</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>gr_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_char_to_float_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_char_to_float_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_uchar_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_char_to_float_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_probe_avg_mag_sqrd_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>gr_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_char_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
